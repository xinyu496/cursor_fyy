# Keil uVision project fY_270.uvprojx, settings and files
target fY_270 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: fy_270 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../UserFiles;../UserFiles/APP/app;../UserFiles/APP/servo;..\Core\Src\servo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../UserFiles/APP/app/: app_ctrl.c
    ../UserFiles/APP/: GEO_Track_C.h GEO_Track_C.lib
  group Servo_linhui
    ../UserFiles/APP/servo/: servo_axis.c servo_controller.c servo_module.c servo_test.c servo_tune.c SFlibhead.h
  group Bsp
    ../UserFiles/Bsp/: bsp_gpio.c bsp_iic.c bsp_timer.c bsp_uart.c SEGGER_RTT.c SEGGER_RTT_printf.c bsp_flash.c
  group Common
    ../UserFiles/Common/: utl_check.c
  group Driver
    ../UserFiles/Driver/: drv_uart.c drv_i2c_eeprom.c
  group ReadMe
    ../Core/Src/: readme.txt
  group Servo
    ../Core/Src/servo/: SF_20240116.c Servolib.lib
software components: CMSIS:CORE 4.3.0
